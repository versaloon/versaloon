# IAR project Versaloon.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_XL; _HARDWARE_VER=0x21; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x0000; CORE_DEBUG=STM32_DBG_SWD
  ICCARM.CCIncludePath2: ; ..\..\; ..\..\..\..\; ..\..\..\..\USB_TO_XXX\; ..\..\..\..\versaloon_usb\; ..\..\..\..\..\..\vsf\; ..\..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\..\vsf\interfaces\; ..\..\..\..\..\..\vsf\interfaces\cpu\stm32\; ..\..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\; ..\..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\Port\IAR\; ..\..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\CMSIS\CM3\CoreSupport; ..\..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\..\..\..\vsf\interfaces\cpu\stm32\hw\STM32F10x_Lib\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\..\vsf\hardware\core\stm32\bsp; ..\..\..\..\..\..\vsf\hardware\core\stm32\bsp\APP; ..\..\..\..\..\..\vsf\hardware\core\stm32\bsp\vsf_cfg
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Versaloon.bin
  ILINK.IlinkOutputFile: Versaloon.out
  ILINK.IlinkIcfFile: VSFCore_STM32.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_XL; _HARDWARE_VER=0x21; __TARGET_CHIP__=stm32; FLASH_LOAD_OFFSET=0x8000; CORE_DEBUG=STM32_DBG_SWD
  ICCARM.CCOptLevel: 3
  group (top)
    ../../: app_cfg.h
    ../../../../: main.c usb_protocol_Versaloon.c
  group Interfaces
    ../../../../../../vsf/hardware/core/stm32/bsp/: app_interfaces.c
  group Interfaces/APP/ADC
    ../../../../../../vsf/hardware/core/stm32/bsp/APP/ADC/: ADC.c
  group Interfaces/APP/EBI
    ../../../../../../vsf/hardware/core/stm32/bsp/APP/EBI/: EBI.c
  group Interfaces/APP/GPIO
    ../../../../../../vsf/hardware/core/stm32/bsp/APP/GPIO/: GPIO.c
  group Interfaces/APP/IIC
    ../../../../../../vsf/hardware/core/stm32/bsp/APP/IIC/: IIC.c
  group Interfaces/APP/SDIO
    ../../../../../../vsf/hardware/core/stm32/bsp/APP/SDIO/: SDIO.c
  group Interfaces/APP/SPI
    ../../../../../../vsf/hardware/core/stm32/bsp/APP/SPI/: SPI.c
  group Interfaces/APP/USART
    ../../../../../../vsf/hardware/core/stm32/bsp/APP/USART/: USART.c
  group USB_TO_XXX
    ../../../../USB_TO_XXX/: CommandProcessor.c USB_TO_ADC.c USB_TO_DAC.c USB_TO_EBI.c USB_TO_GPIO.c USB_TO_IIC.c USB_TO_PWM.c USB_TO_SPI.c USB_TO_USART.c USB_TO_XXX.c
  group versaloon_usb
    ../../../../versaloon_usb/: vsfusbd_Versaloon.c
  group vsf/dal
    ../../../../../../vsf/dal/: dal.c
  group vsf/dal/cfi
    ../../../../../../vsf/dal/cfi/: cfi_drv.c
  group vsf/dal/df25xx
    ../../../../../../vsf/dal/df25xx/: df25xx_drv.c
  group vsf/dal/df45xx
    ../../../../../../vsf/dal/df45xx/: df45xx_drv.c
  group vsf/dal/ee24cxx
    ../../../../../../vsf/dal/ee24cxx/: ee24cxx_drv.c
  group vsf/dal/ee93cx6
    ../../../../../../vsf/dal/ee93cx6/: ee93cx6_drv.c
  group vsf/dal/mal
    ../../../../../../vsf/dal/mal/: mal.c
  group vsf/dal/mic2826
    ../../../../../../vsf/dal/mic2826/: mic2826_drv.c
  group vsf/dal/nand
    ../../../../../../vsf/dal/nand/: nand_drv.c
  group vsf/dal/nrf24l01
    ../../../../../../vsf/dal/nrf24l01/: nrf24l01_drv.c
  group vsf/dal/sd
    ../../../../../../vsf/dal/sd/: sd_common.c sd_sdio_drv.c sd_spi_drv.c
  group vsf/dal/stream
    ../../../../../../vsf/dal/stream/: stream.c
  group vsf/dal/usart_stream
    ../../../../../../vsf/dal/usart_stream/: usart_stream.c
  group vsf/interfaces
    ../../../../../../vsf/interfaces/: interfaces.c
  group vsf/interfaces/cpu/stm32
    ../../../../../../vsf/interfaces/cpu/stm32/: core.c
  group vsf/interfaces/cpu/stm32/adc
    ../../../../../../vsf/interfaces/cpu/stm32/adc/: STM32_ADC.c
  group vsf/interfaces/cpu/stm32/ebi
    ../../../../../../vsf/interfaces/cpu/stm32/ebi/: STM32_EBI.c
  group vsf/interfaces/cpu/stm32/eint
    ../../../../../../vsf/interfaces/cpu/stm32/eint/: STM32_EINT.c
  group vsf/interfaces/cpu/stm32/flash
    ../../../../../../vsf/interfaces/cpu/stm32/flash/: STM32_FLASH.c
  group vsf/interfaces/cpu/stm32/gpio
    ../../../../../../vsf/interfaces/cpu/stm32/gpio/: STM32_GPIO.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport
    ../../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup
    ../../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver
    ../../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32_USB-FS-Device_Driver/src/: usb_mem.c usb_regs.c
  group vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver
    ../../../../../../vsf/interfaces/cpu/stm32/hw/STM32F10x_Lib/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c
  group vsf/interfaces/cpu/stm32/sdio
    ../../../../../../vsf/interfaces/cpu/stm32/sdio/: STM32_SDIO.c
  group vsf/interfaces/cpu/stm32/spi
    ../../../../../../vsf/interfaces/cpu/stm32/spi/: STM32_SPI.c
  group vsf/interfaces/cpu/stm32/timer
    ../../../../../../vsf/interfaces/cpu/stm32/timer/: STM32_TIM.c
  group vsf/interfaces/cpu/stm32/usart
    ../../../../../../vsf/interfaces/cpu/stm32/usart/: STM32_USART.c
  group vsf/interfaces/cpu/stm32/usbd
    ../../../../../../vsf/interfaces/cpu/stm32/usbd/: STM32_USBD.c
  group vsf/stack/usb_device
    ../../../../../../vsf/stack/usb_device/: vsf_usbd.c
  group vsf/stack/usb_device/CLASS/CDC
    ../../../../../../vsf/stack/usb_device/class/CDC/: vsfusbd_CDCACM.c
  group vsf/stack/usb_device/CLASS/HID
    ../../../../../../vsf/stack/usb_device/class/HID/: vsfusbd_HID.c
  group vsf/stack/usb_device/CLASS/MSC
    ../../../../../../vsf/stack/usb_device/class/MSC/: SCSI.c vsfusbd_MSC_BOT.c
  group vsf/tool/buffer
    ../../../../../../vsf/tool/buffer/: buffer.c
  group vsf/tool/list
    ../../../../../../vsf/tool/list/: list.h
  group vsf_cfg
    ../../../../../../vsf/hardware/core/stm32/bsp/vsf_cfg/: dal_cfg.h interfaces_cfg.h vsf_usbd_cfg.h
