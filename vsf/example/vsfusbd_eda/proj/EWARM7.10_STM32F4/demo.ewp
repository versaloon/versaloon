# IAR project demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401xB ST STM32F401xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32F401xx; __TARGET_CHIP__=stm32f4; FLASH_LOAD_OFFSET=0x0000; CORE_DEBUG=STM32F4_DBG_JTAG_SWD
  ICCARM.CCIncludePath2: ; ..\..; ..\..\vsf_cfg; ..\..\..\..\..\vsf; ..\..\..\..\..\vsf\compiler\IAR; ..\..\..\..\..\vsf\interfaces; ..\..\..\..\..\vsf\interfaces\cpu\stm32f4
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: STM32F4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F401xx; __TARGET_CHIP__=stm32f4; FLASH_LOAD_OFFSET=0x8000; CORE_DEBUG=STM32F4_DBG_NONE
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: flash.bin
  group (top)
    ../../: main.c
  group vsf/dal/mal
    ../../../../dal/mal/: mal.c
  group vsf/framework/vsfsm
    ../../../../framework/vsfsm/: vsfsm.c
  group vsf/framework/vsftimer
    ../../../../framework/vsftimer/: vsftimer.c
  group vsf/interfaces
    ../../../../interfaces/: interfaces.c
  group vsf/interfaces/cpu/stm32f4
    ../../../../interfaces/cpu/stm32f4/: core.c
  group vsf/interfaces/cpu/stm32f4/gpio
    ../../../../interfaces/cpu/stm32f4/gpio/: STM32F4_GPIO.c
  group vsf/interfaces/cpu/stm32f4/startup
    ../../../../interfaces/cpu/stm32f4/startup/iar/: startup_stm32f401xx.s
  group vsf/interfaces/cpu/stm32f4/usbd
    ../../../../interfaces/cpu/stm32f4/usbd/: STM32F4_USBD.c
  group vsf/stack/usb/device
    ../../../../stack/usb/device/: vsfusbd.c
  group vsf/stack/usb/device/class/HID
    ../../../../stack/usb/device/class/HID/: vsfusbd_HID.c
  group vsf/stack/usb/device/class/MSC
    ../../../../stack/usb/device/class/MSC/: SCSI.c vsfusbd_MSC_BOT.c
  group vsf/tool/buffer
    ../../../../tool/buffer/: buffer.c
  group vsf/tool/fakefat32
    ../../../../tool/fakefat32/: fakefat32.c
  group vsf/tool/list
    ../../../../tool/list/: list.c
  group vsf/tool/mal_embflash
    ../../../../tool/mal_embflash/: mal_embflash.c
  group vsf/tool/mal_in_mal
    ../../../../tool/mal_in_mal/: mal_in_mal.c
  group vsf_cfg
    ../../vsf_cfg/: dal_cfg.h vsf_usbd_cfg.h
    ./: interfaces_cfg.h
